Commit message: Update environment

File: crawler_gym/agents/resources/crawler/crawler_caster.urdf (robot description, URDF)
Before this commit: robot crawler, 6 links, 5 joints
Links:
- link base_footprint: mass None -> 1e-10
